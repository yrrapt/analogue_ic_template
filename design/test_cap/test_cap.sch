v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1230 -580 1230 -560 { lab=yyy}
N 1230 -500 1230 -470 { lab=xxx}
C {cap_mim_m3_1.sym} 1230 -530 0 1 {name=C1 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/iopin.sym} 1230 -470 1 0 {name=p1 lab=xxx}
C {devices/iopin.sym} 1230 -580 3 0 {name=p2 lab=yyy}
